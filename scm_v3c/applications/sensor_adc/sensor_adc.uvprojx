# Keil uVision project sensor_adc.uvprojx, settings and files
target sensor_adc (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(10000000) ELITTLE
  output: sensor_adc +hex
  AfterMake: fromelf --bin .\Objects\sensor_adc.axf -o .\Objects\sensor_adc.bin
  AfterMake: fromelf -cvf .\Objects\sensor_adc.axf -o .\Objects\disasm.txt
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ../../
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group app
    ./: sensor_adc.c adc_msb.c adc_msb.h fixed_point.h sensor.h sensor_capacitor.c sensor_capacitor.h sensor_gpio.c sensor_gpio.h sensor_potentiometric.c sensor_potentiometric.h sensor_resistive.c sensor_resistive.h sensors.c sensors.h time_constant.c time_constant.h
    ../channel_cal/: channel_cal.c channel_cal.h
    ../../: tuning.c tuning.h ieee_802_15_4.c ieee_802_15_4.h
  group drv
    ../../: cm0dsasm.s Memory_Map.h retarget.c optical.c optical.h radio.c radio.h adc.c adc.h gpio.c gpio.h uart.c uart.h rftimer.c rftimer.h scum_defs.h scm3c_hw_interface.h scm3c_hw_interface.c
